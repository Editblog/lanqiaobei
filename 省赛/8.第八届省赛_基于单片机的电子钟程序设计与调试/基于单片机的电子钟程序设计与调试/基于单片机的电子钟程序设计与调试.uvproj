# Keil uVision project 基于单片机的电子钟程序设计与调试.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 基于单片机的电子钟程序设计与调试 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\driver
  group Source Group 1
    ./: main.c
  group driver
    ./driver/: ds1302.c onewire.c
